# Keil uVision project Furbo.uvprojx, settings and files
target Furbo (6140000::V6.14::ARMCLANG)
  device: M252SD2AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.9
  cpu: IRAM(0x20000000,0x3000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: Furbo
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\..\Library\Nuvoton\M251_252_Series\CMSIS\Include;..\..\Library\Nuvoton\M251_252_Series\StdDriver\inc;..\..\Library\Nuvoton\M251_252_Series\Device\Nuvoton\M251\Include;..\Core\Inc;..\MYx\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group CMSIS
    ../../Library/Nuvoton/M251_252_Series/Device/Nuvoton/M251/Source/: system_M251.c
    ../../Library/Nuvoton/M251_252_Series/Device/Nuvoton/M251/Source/ARM/: startup_M251.s
  group Library
    ../../Library/Nuvoton/M251_252_Series/StdDriver/src/: clk.c retarget.c sys.c uart.c gpio.c
  group Core
    ../Core/Src/: main.c
    ../Core/Inc/: main.h
  group MYx
    ../MYx/Core/Src/: My_Func.c MyDev_LED.c MyFunc_CLI.c MyFunc_CLI_Commands.c MyMCU_GPIO.c MyMCU_SYS.c MyMCU_UART.c MyDev_Motor.c
software components: CMSIS:CORE 5.4.0
